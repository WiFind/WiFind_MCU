# Keil uVision project WiFind.uvprojx, settings and files
target WiFind Configuration (5060020::V5.06 (build 20)::ARMCC)
  device: STM32L053C8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: WiFind Configuration
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L053xx
  c misc: --C99
  c include: ..\Inc;..\Drivers\STM32L0xx_HAL_Driver\Inc;..\Drivers\STM32L0xx_HAL_Driver\Inc\Legacy;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32L0xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Src
    ../Src/: main.c stm32l0xx_hal_msp.c stm32l0xx_it.c
  group HAL
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_cortex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_uart.c stm32l0xx_hal_usart.c stm32l0xx_hal_dma.c stm32l0xx_hal_uart_ex.c
software components: CMSIS:CORE 4.1.0, CMSIS:RTOS:Keil RTX 4.78.0, Device:Startup 1.0.0
